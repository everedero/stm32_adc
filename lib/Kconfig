## lib/Kconfig
```kconfig
# Copyright (c) 2021 Legrand North America, LLC.
# SPDX-License-Identifier: Apache-2.0

menu "TinyOSC libraries"

rsource "tinyosc/Kconfig"

endmenu
```
